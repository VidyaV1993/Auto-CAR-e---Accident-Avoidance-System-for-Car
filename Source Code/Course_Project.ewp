# IAR project Course_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.3.156\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.5\arm\CMSIS\Include; F:\Embedded System Design\Course Project\oled_i2c\include; C:\ti\TivaWare_C_Series-2.1.3.156; F:\Embedded System Design\Course Project\TM4C123G_IoT_CodeComposerStudio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: init.c init.h main.c
  group Interrupt
    ./: cstartup_M.c interrupt.c
  group oled
    oled_i2c/include/: Draw2D.h Font5x7.h Font8x16.h i2c_oled.c i2c_oled.h I2C_SSD1306Z.c I2C_SSD1306Z.h
  group PWM Motor
    oled_i2c/include/: PWM_Motor.c
